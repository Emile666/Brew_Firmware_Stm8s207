# IAR project brew_stm8s207.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S207R8 STM8S207R8
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: brew_stm8s207.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 0
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: adc.c adc.h brew_stm8s207.c brew_stm8s207.h command_interpreter.c command_interpreter.h delay.c delay.h Dhcp.c Dhcp.h Dns.c Dns.h eep.c eep.h Ethernet.c Ethernet.h EthernetClient.c EthernetClient.h EthernetServer.c EthernetServer.h i2c_bb.c i2c_bb.h max7219.c max7219.h misc.c misc.h one_wire.c one_wire.h pwm.c pwm.h ring_buffer.h scheduler.c scheduler.h socket.c socket.h spi.c spi.h stm8_hw_init.c stm8_hw_init.h uart.c uart.h Udp.c Udp.h util.h w5500.c w5500.h webserver.c webserver.h
